<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\fsm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\functions.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\functions.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Module 3\lcd_dog_driver.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Module 3\lcd_dog_driver.h</name>
  </file>
</project>


