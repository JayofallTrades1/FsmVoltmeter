<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\..\..\Downloads\keyscan_isr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\Downloads\kpd2dsp.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\Downloads\lcd.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\Downloads\lcd_dog_iar_driver.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\Downloads\lcd_ext.c</name>
  </file>
</project>


