<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\keypad.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Kpd2dsp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


