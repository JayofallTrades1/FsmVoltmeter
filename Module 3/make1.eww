<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC161S626_display.ewp</path>
  </project>
  <batchBuild/>
</workspace>


