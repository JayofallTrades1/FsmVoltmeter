<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC161S626.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC161S626_display.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simulated_ntc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


